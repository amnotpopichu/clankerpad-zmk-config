## boards/shields/clankerpad/Kconfig.defconfig
```kconfig
if SHIELD_CLANKERPAD

config ZMK_KEYBOARD_NAME
    default "Clankerpad"

endif # SHIELD_CLANKERPAD
```
